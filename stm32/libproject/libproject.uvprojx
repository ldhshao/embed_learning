# Keil uVision project libproject.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: libproject +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\lib\cmsis\inc;.\lib\periphdriver\inc;.\lib\periphdriver\template\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group usr
    ./usr/: main.c
  group startup
    ./lib/startup/: startup_stm32f10x_hd.s
  group periphdriver
    ./lib/periphdriver/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c
    ./lib/periphdriver/inc/: stm32f10x_gpio.h stm32f10x_rcc.h
    ./lib/periphdriver/template/: stm32f10x_it.c
    ./lib/periphdriver/template/inc/: stm32f10x_conf.h stm32f10x_it.h RTE_Components.h
  group cmsis
    ./lib/cmsis/: system_stm32f10x.c
    ./lib/cmsis/inc/: core_cm3.h core_cmFunc.h core_cmInstr.h stm32f10x.h system_stm32f10x.h
  group app
    ./app/led/: led.c led.h
    ./app/rcc/: rcc.c rcc.h
    ./app/beep/: beep.c beep.h
    ./app/key/: key.c key.h
    ./app/exti/: exti.c
