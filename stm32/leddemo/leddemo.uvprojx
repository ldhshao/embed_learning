# Keil uVision project leddemo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: leddemo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.2.0\Device\Include;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group New Group
    ./src/: main.c startup_stm32f10x_hd.s stm32f10x.h
